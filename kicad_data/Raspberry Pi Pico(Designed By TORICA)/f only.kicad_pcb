# Repository yoshi-a2/TORICAberry-Pi-Bico

File README.md:

# TORICAberry Pi Bico
26代機基板表面実装化のための試作  
### Bico素子配置
TORICAberry Pi Bico  1st editionの素子配置は以下の通り．  
裏面のLEDについて，kicad上の配線のアノード，カソードが逆になっている（設計ミスです）．以下の写真内，注意書き（「SW側がGNDになるように」）の通りに配置すれば問題nothing．抵抗かキャパシタかはキロとかナノとかマイクロをみて常識的に判断してください．「no」は「No-Fit」のことで，何も実装しないことを意味します．ブリッジしないようにだけ気をつけて  
**↓クリックで拡大↓**  

### Bico基板データ
[1st Edition 基板データ](kicad_data/1stedition)

### リフローの手順
1. ステンシルをエタノールで拭く
2. 基板の裏面（スイッチを実装する面）を上にしてステンシルの位置決めをする
3. 使う分量のクリームはんだを取り出し，適量の無水エタノールをスポイトで滴下し，よく混ぜる（はんだが乾燥していなくて滑らかなら，エタノールは要らん．ゆるくしすぎるとすぐブリッジしちゃう）
4. ステンシルの上にクリームはんだを乗せ，カードかなんかで伸ばす
5. クリームはんだに蓋をして揮発を抑える
6. ステンシルのすべての穴にいい感じに半田が埋め込まれたことを確認する
7. ステンシルを外し，素子配置に従ってピンセットで部品を乗せる
8. トースターで[焼き焼きする](https://github.com/yoshi-a2/Reflow_toaster)
9. トースターから取り出し，触ってちょっとあったかいぐらいまで冷ます
10. ~~耐熱(最低200℃)のテープで，実装したスイッチとLED等を固定する~~（表面の焼きの時に落下しないように)（耐熱ボンドがあればボンドで固定．ボンドあるなら6の時にやった方がいいか）
11. ステンシルをエタノールで拭く
12. 基板の表面を上にして，ステンシルの位置決めをする
13. 3~8を再び実行する
14. ブリッジしていないことをテスターと目で確認する
15. 基板をエタノールで拭いて洗浄する
16. 動作確認をして完成！！

**※注意点**
- トースター周りの配線を入念に確認し，**ショートや火災を防止**する．扱う電気が**AC100V**であることの危険性を認識する．
- 空気中のエタノール濃度が高いと感じたり，エタノールをこぼしたりした際には換気をしっかり行い，ヒートガンやトースターはんだごての使用を一時的に控える．他班が引火の可能性のある作業をしていたら声をかけて中断させる．
- Pb入りのクリームはんだを使う際には**使い捨ての手袋とマスクの着用，換気**をしっかりする
- 無水エタノールは吸湿性，揮発性が高く，ふたを開ける時間が長いと徐々にボトル内のエタノール濃度が薄くなり，逆に空気中のエタノール濃度は高くなる．**蓋を開ける時間を最小限**にし，**直射日光の当たらないできるだけ涼しいところで保管**するよう心掛ける．
- Pbフリーか否かに関わらず作業後は**石鹸でしっかり手を洗う**

# 反省会
## 第1回(2025/06/17,18)
- 三端子レギュレーターの内部短絡により，2,3番ピン(3.3VとGND)が短絡状態になって発熱
- レギュレーターがいかれたのは合計2回トーストしたからか？
- LEDのサイズを大きくして，裏面（typeC側）は全部手はんだにするのがいいと思う
- 表面の大量コンデンサゾーンのコンデンサ2個がリフロー後に紛失．最後の方に乗せたエリアであり，それまでにいろいろ時間かかって半田が乾きかけてしまい，その状態で乗せたせいでどっか吹っ飛んだか？
- RP2040のステンシルはんだ塗りむず過ぎ．手はんだするのもむずい．多分こて先が太いのも原因．
- 両面テープごみすぎた．2回目のリフロー後．スイッチとかtypeCは取れてるしテープ焦げまくって粘着物質も基板上に残ってた．

# 備忘録
## 配線について
- 配線の途中で配線幅を変更する方法(差動ペアのネットクラス定義使用時：USB)
  - 幅0.8mmギャップ0.15mmを定義して，抵抗側から途中まで配線
  - 幅0.3mmギャップ0.15mmを指定して，Type-C側からさっきの配線につなぐ
  - 編集 > ティアドロップを編集... > 「配線から配線」にチェックをつけて適用する
- てか，すべての基板にティアドロップ採用すべきじゃね？　パッド-配線，配線-配線，ビア-配線

## KiCad design kicad_data/Raspberry Pi Pico(Designed By TORICA)/f only.kicad_pcb

Parts:
C1, C4, C6, C7, C8, C9, C10, C11, C16: 100n; C_0201_0603Metric
C2: 1n; C_0201_0603Metric
C3, C5, C12, C13: 2.2u; C_0201_0603Metric
C14, C15: 15p; C_0201_0603Metric
C17: 10u; C_0402_1005Metric
C18: 22u; C_0603_1608Metric
D1: LED; LED_0201_0603Metric
D2: D_Schottky; Schottly new SBR2U30P1
J1: USB_C_Receptacle; Type-C
J2, J4: Conn_01x16_Socket; PinSocket_1x16_P2.54mm_Vertical
Q1: DMG1012T; MOSFET DMG1012T
R1: 200K; R_0402_1005Metric
R2: 100K; R_0402_1005Metric
R3, R4: 27; R_0402_1005Metric
R5: 200; R_0402_1005Metric
R6: 1; R_0402_1005Metric
R7, R9: 1k; R_0402_1005Metric
R8, R11: NO-FIT; R_0201_0603Metric
R10: 470; R_0402_1005Metric
R12, R13: 5.1k; R_0402_1005Metric
R14: 10k; R_0201_0603Metric
R15: 5.6k; R_0402_1005Metric
SW1, SW2: SW_Push; Tactil Switch
TP1, TP2, TP3, TP4, TP5: TestPoint; TestPoint_Pad_1.0x1.0mm
U1: RP2040; QFN-56-1EP_7x7mm_P0.4mm_EP3.2x3.2mm
U2: Flash Memory; Winbond_USON-8-1EP_3x2mm_P0.5mm_EP0.2x1.6mm
U3: OKI-78SR-3.3_1.5-W36H-C; 3pin regulator
Y1: Crystal_GND23; 12MHz

Connections:
+1V1: C5.2, C7.2, C9.2, U1.23 (DVDD), U1.45 (VREG_VOUT), U1.50 (DVDD)
+3V3: C1.2, C3.2, C4.2, C6.2, C8.2, C10.2, C11.2, C13.1, C16.1, C18.1, J4.3, Q1.1 (G), R5.1, R11.1, U1.1 (IOVDD), U1.10 (IOVDD), U1.22 (IOVDD), U1.33 (IOVDD), U1.42 (IOVDD), U1.44 (VREG_IN), U1.48 (USB_VDD), U1.49 (IOVDD), U2.8 (VCC), U3.3 (OUT)
/ADC_VREF: R5.2, R6.1
/GPIO0: J2.1, U1.2 (GPIO0)
/GPIO1: J2.2, U1.3 (GPIO1)
/GPIO2: J2.3, U1.4 (GPIO2)
/GPIO3: J2.4, U1.5 (GPIO3)
/GPIO4: J2.5, U1.6 (GPIO4)
/GPIO5: J2.6, U1.7 (GPIO5)
/GPIO6: J2.7, U1.8 (GPIO6)
/GPIO7: J2.8, U1.9 (GPIO7)
/GPIO8: J2.9, U1.11 (GPIO8)
/GPIO9: J2.10, U1.12 (GPIO9)
/GPIO10: J2.11, U1.13 (GPIO10)
/GPIO11: J2.12, U1.14 (GPIO11)
/GPIO12: J2.13, U1.15 (GPIO12)
/GPIO13: J2.14, U1.16 (GPIO13)
/GPIO14: J2.15, U1.17 (GPIO14)
/GPIO15: J4.15, U1.18 (GPIO15)
/GPIO16: J4.14, U1.27 (GPIO16)
/GPIO17: J4.13, U1.28 (GPIO17)
/GPIO18: J4.12, U1.29 (GPIO18)
/GPIO19: J4.11, U1.30 (GPIO19)
/GPIO20: J4.10, U1.31 (GPIO20)
/GPIO21: J4.9, U1.32 (GPIO21)
/GPIO22: J4.8, U1.34 (GPIO22)
/GPIO23: J4.7, U1.35 (GPIO23)
/GPIO24: R14.2, R15.1, U1.36 (GPIO24)
/GPIO25: R10.1, U1.37 (GPIO25)
/GPIO26_ADC0: J4.6, U1.38 (GPIO26_ADC0)
/GPIO27_ADC1: J4.5, U1.39 (GPIO27_ADC1)
/GPIO28_ADC2: J4.4, U1.40 (GPIO28_ADC2)
/GPIO29_ADC3: Q1.2 (S), U1.41 (GPIO29_ADC3)
/QSPI_SCLK: U1.52 (QSPI_SCLK), U2.6 (CLK)
/QSPI_SD0: U1.53 (QSPI_SD0), U2.5 (DI_IOD)
/QSPI_SD1: U1.55 (QSPI_SD1), U2.2 (DO_IO1)
/QSPI_SD2: U1.54 (QSPI_SD2), U2.3 (WP_IO2)
/QSPI_SD3: U1.51 (QSPI_SD3), U2.7 (HOLD_IO3)
/QSPI_SS: R9.2, R11.2, U1.56 (QSPI_SS), U2.1 (CS)
/RUN: SW2.1, U1.26 (RUN)
/SWCLK: U1.24 (SWCLK); also elsewhere on the board
/SWDIO: U1.25 (SWD); also elsewhere on the board
/USB_D+: J1.A6 (D+), J1.B6 (D+), R3.1, TP4.1
/USB_D-: J1.A7 (D-), J1.B7 (D-), R4.1, TP3.1
/VBUS: D2.2 (A), J1.A4 (VBUS), J4.1, R15.2
/VSYS: C17.1, D2.1 (K), J4.2, R1.1, TP5.1, U3.1 (IN)
/XIN: C14.2, R8.1, U1.20 (XIN), Y1.1
/XOUT: R7.2, R8.2, U1.21 (XOUT)
/XR: C15.2, R7.1, Y1.4
GND: C1.1, C2.2, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.2, C14.1, C15.1, C16.2, C17.2, C18.2, D1.1 (K), J1.A1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.16, J4.16, R2.2, R12.2, R13.2, R14.1, SW1.1, SW2.2, U1.19 (TESTEN), U1.57 (GND), U2.4 (GND), U3.2 (GND), Y1.2, Y1.3; also elsewhere on the board
unnamed: D1.2 (A), R10.2, TP2.1
unnamed: J1.A5 (CC1), R12.1
unnamed: J1.B5 (CC2), R13.1
unnamed: C2.1, Q1.3 (D), R1.2, R2.1
unnamed: R9.1, SW1.2, TP1.1
unnamed: C12.2, R6.2, U1.43 (ADC_AVDD)
unnamed: R4.2, U1.46 (USB_DM)
unnamed: R3.2, U1.47 (USB_DP)

Notes on the sheet:
なにこれ笑(完了)
LED(完了)
RP2040(完了)
PICO size 21 × 51 mm
Crystal Oscillator(完了)
Power Unit(残：typeC化)
Reset(完了)
Flash Memory(完了)
Pin Header(完了)
BOOTSEL(完了)

Board: 2 copper layers, 51 parts (5 on the bottom side), 58 nets, no tracks yet.

Other parts of the board:
J3: Conn_01x03_Socket; PinSocket_1x03_P2.54mm_Vertical

Their connections:
/SWCLK: J3.3; also elsewhere on the board
/SWDIO: J3.1; also elsewhere on the board
GND: J3.2; also elsewhere on the board

## Commit log

2025-05-28 Create images
2025-05-28 Rename Bcio 素子配置front.png to Bico 素子配置front.png
2025-05-28 Create a
2025-05-28 Create TORICAberry Pi Bico 1st edition
2025-05-28 Rename TORICAberry Pi Bico 1st edition to TORICAberryPiBico1stedition
2025-05-28 Rename TORICAberryPiBico1stedition to 1st_edition
2025-06-18 Rename スクリーンショット 2025-06-18 142245.png to Bico 素子配置front.png
